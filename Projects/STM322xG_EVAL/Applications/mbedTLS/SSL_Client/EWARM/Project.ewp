# IAR project Project.ewp, settings and files
configuration STM322xG-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F217IG ST STM32F217IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F217xx; USE_STM322xG_EVAL; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_LCD
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include; ..\..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM322xG_EVAL; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\..\Middlewares\Third_Party\LwIP\system\OS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Middlewares\Third_Party\mbedTLS\include; ..\..\..\..\..\..\Utilities\Log
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f217xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f217xx.s
  group Application/User
    ../Src/: ethernetif.c hardware_rng.c main.c net_sockets.c ssl_client.c stm32f2xx_hal_msp.c stm32f2xx_hal_timebase_tim.c stm32f2xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_io.c stm322xg_eval_lcd.c stm322xg_eval_sram.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_cryp.c stm32f2xx_hal_dma.c stm32f2xx_hal_eth.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_hash.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rng.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_ll_fsmc.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Middlewares/LwIP/system
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
