# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207IG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM322xG_EVAL;../../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff_gen_drv.c ff.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_eth.c stm32f2xx_hal_pwr.c stm32f2xx_hal_tim.c stm32f2xx_hal_cryp.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_crc.c stm32f2xx_hal_hash.c stm32f2xx_hal.c stm32f2xx_hal_i2c.c stm32f2xx_hal_adc.c stm32f2xx_hal_spi.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_pccard.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_hcd.c stm32f2xx_hal_rng.c stm32f2xx_hal_sram.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_nor.c stm32f2xx_hal_nand.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_ll_usb.c stm32f2xx_hal_can.c stm32f2xx_hal_sd.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rtc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_uart.c stm32f2xx_hal_dac.c stm32f2xx_hal_flash.c stm32f2xx_hal_i2s.c stm32f2xx_hal_irda.c stm32f2xx_hal_rtc_ex.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_pcd.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_usart.c stm32f2xx_hal_rcc.c stm32f2xx_hal_adc_ex.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Application/User
    ../Src/: main.c decode.c jdata_conf.c stm32f2xx_it.c
  group Middlewares/LibJPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jdcoefct.c jdatadst.c jdatasrc.c jccoefct.c jidctint.c jdarith.c jcinit.c jccolor.c jfdctint.c jfdctfst.c jquant2.c jdhuff.c jaricom.c jcarith.c jdmaster.c jcmarker.c jdtrans.c jcomapi.c jdpostct.c jcmainct.c jerror.c jctrans.c jcprepct.c jdcolor.c jdapimin.c jcdctmgr.c jcapistd.c jmemnobs.c jcsample.c jcapimin.c jddctmgr.c jdsample.c jidctfst.c jdinput.c jchuff.c jfdctflt.c jutils.c jdmerge.c jdmarker.c jdapistd.c jcmaster.c jcparam.c jmemmgr.c jquant1.c jidctflt.c jdmainct.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval_lcd.c stm322xg_eval_sram.c stm322xg_eval_sd.c stm322xg_eval.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
software components: CMSIS:CORE 4.3.0
