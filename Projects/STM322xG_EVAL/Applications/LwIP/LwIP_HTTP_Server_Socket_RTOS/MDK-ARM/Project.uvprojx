# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM322xG_EVAL;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/apps/httpd
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c tasks.c queue.c list.c timers.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c ip4_frag.c igmp.c etharp.c dhcp.c ip4_addr.c ip4.c icmp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_eth.c stm32f2xx_hal_sram.c stm32f2xx_hal_pwr.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal.c stm32f2xx_hal_uart.c stm32f2xx_hal_flash.c stm32f2xx_hal_i2c.c stm32f2xx_hal_i2s.c stm32f2xx_hal_adc.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_rcc.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_adc_ex.c
  group Application/Utilities
    ../../../../../../Utilities/Log/: lcd_log.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: netbuf.c tcpip.c api_msg.c err.c sockets.c netifapi.c api_lib.c netdb.c
  group Application/User
    ../Src/: app_ethernet.c main.c stm32f2xx_hal_timebase_tim.c httpserver-socket.c stm32f2xx_it.c ethernetif.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_io.c stm322xg_eval.c stm322xg_eval_lcd.c stm322xg_eval_sram.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: stats.c mem.c tcp.c inet_chksum.c netif.c timeouts.c sys.c def.c ip.c init.c raw.c tcp_out.c pbuf.c dns.c memp.c udp.c tcp_in.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
software components: CMSIS:CORE 4.3.0
