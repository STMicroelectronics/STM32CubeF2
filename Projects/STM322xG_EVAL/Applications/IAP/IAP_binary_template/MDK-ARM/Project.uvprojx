# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (ARM-ADS)
  device: STM32F207IGHx STMicroelectronics
  cpu: IROM(0x08008000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/BSP/STM322xG_EVAL;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Application/User
    ../src/: main.c stm32f2xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_io.c
  group Drivers/CMSIS
    ../src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_sram.c stm32f2xx_ll_fsmc.c
software components: CMSIS:CORE 4.3.0
