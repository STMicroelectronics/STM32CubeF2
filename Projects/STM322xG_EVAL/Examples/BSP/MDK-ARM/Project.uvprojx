# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\..\Drivers\STM32F2xx_HAL_Driver\Inc;..\..\..\..\..\Drivers\BSP\STM322xG_EVAL;..\..\..\..\..\Drivers\BSP\Components\ili9325;..\..\..\..\..\Drivers\BSP\Components\ili9320;..\..\..\..\..\Drivers\BSP\Components\stmpe811;..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\Utilities\Log
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_sram.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_dma.c stm32f2xx_hal_uart.c stm32f2xx_hal_pwr.c stm32f2xx_hal_sd.c stm32f2xx_hal_rcc.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Example/User
    ../Src/: touchscreen.c sd.c joystick.c stm32f2xx_it.c lcd.c ts_calibration.c main.c eeprom.c log.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval_eeprom.c stm322xg_eval_sd.c stm322xg_eval.c stm322xg_eval_lcd.c stm322xg_eval_ts.c stm322xg_eval_io.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
software components: CMSIS:CORE 4.1.0
