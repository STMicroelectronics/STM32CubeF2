# Keil uVision project Project.uvprojx, settings and files
target STM322xG_EVAL (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM322xG_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM322xG_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM322xG_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Example/User
    ../Src/: stm32f2xx_hal_timebase_rtc_wakeup.c stm32f2xx_it.c main.c
  group Drivers/BSP/STM322xG_EVAL
    ../../../../../../Drivers/BSP/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_io.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_uart.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_tim.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rtc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_dma.c stm32f2xx_hal.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c
software components: CMSIS:CORE 4.3.0
