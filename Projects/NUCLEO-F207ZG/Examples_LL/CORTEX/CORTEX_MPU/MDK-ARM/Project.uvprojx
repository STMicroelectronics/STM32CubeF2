# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-F207ZG (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: NUCLEO-F207ZG
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F207xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000U
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc
  library: MicroLIB
  group Drivers/STM32F2xx_LL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_utils.c
  group Doc
    ../: readme.txt
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Example/User
    ../Src/: stm32f2xx_it.c main.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
software components: CMSIS:CORE 4.3.0
