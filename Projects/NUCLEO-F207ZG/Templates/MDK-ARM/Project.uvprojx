# Keil uVision project Project.uvprojx, settings and files
target STM32F207xG_Nucleo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F207xG_Nucleo
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM32F2XX_NUCLEO_144
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../Drivers/STM32F2xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_sdmmc.c stm32f2xx_hal_pcd.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_hcd.c stm32f2xx_hal_i2s.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_irda.c stm32f2xx_hal_pwr_ex.c stm32f2xx_ll_usb.c stm32f2xx_hal_eth.c stm32f2xx_hal_exti.c stm32f2xx_hal_pccard.c stm32f2xx_hal_hash.c stm32f2xx_hal_dma.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_dac.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_smartcard.c stm32f2xx_hal_usart.c stm32f2xx_hal_nand.c stm32f2xx_hal_dcmi.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal.c stm32f2xx_hal_mmc.c stm32f2xx_hal_rtc.c stm32f2xx_hal_wwdg.c stm32f2xx_hal_i2c.c stm32f2xx_hal_sd.c stm32f2xx_hal_rng.c stm32f2xx_hal_nor.c stm32f2xx_hal_rcc.c stm32f2xx_hal_can.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_adc.c stm32f2xx_hal_crc.c stm32f2xx_hal_spi.c stm32f2xx_hal_uart.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cryp.c
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Example/User
    ../Src/: main.c stm32f2xx_hal_msp.c stm32f2xx_it.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
