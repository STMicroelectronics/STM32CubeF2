# Keil uVision project Project.uvprojx, settings and files
target STM32207ZG_Nucleo (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32207ZG_Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM32F2XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32F2xx_Nucleo_144;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Example/User
    ../Src/: stm32f2xx_it.c main.c sd.c joystick.c lcd.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/BSP/STM32F2xx_Nucleo
    ../../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash.c stm32f2xx_hal_rcc.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_spi.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal.c stm32f2xx_hal_gpio.c stm32f2xx_hal_adc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr_ex.c
software components: CMSIS:CORE 4.1.0
