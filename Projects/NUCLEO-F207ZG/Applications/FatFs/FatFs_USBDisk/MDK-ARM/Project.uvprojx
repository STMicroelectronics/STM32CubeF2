# Keil uVision project Project.uvprojx, settings and files
target STM32F207ZG_NUCLEO_144 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207ZG_NUCLEO_144
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F207xx,USE_HAL_DRIVER,USE_STM32F2XX_NUCLEO_144,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F2xx_Nucleo
    ../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_dma.c stm32f2xx_ll_usb.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_spi.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_sram.c stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_hal_rcc_ex.c stm32f2xx_ll_sdmmc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_uart.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_core.c usbh_pipes.c usbh_ioreq.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: main.c usbh_conf.c stm32f2xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Doc
    ../: readme.txt
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
  group Middlewares/FatFs/Drivers
    ../../../../../../Middlewares/Third_Party/FatFs/src/drivers/: usbh_diskio.c
software components: CMSIS:CORE 4.1.0
