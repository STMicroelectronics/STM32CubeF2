# Keil uVision project Project.uvprojx, settings and files
target STM32F207ZG_Nucleo_USBD-FS (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207ZG_Nucleo_USBD-FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM32F2XX_NUCLEO_144,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Inc
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: usbd_dfu_flash.c main.c usbd_desc.c usbd_conf.c stm32f2xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Middlewares/STM32_USBD_Library/Class/DFU
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_spi.c stm32f2xx_hal_gpio.c stm32f2xx_hal_pcd.c stm32f2xx_ll_usb.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_ll_fsmc.c stm32f2xx_hal_rcc.c stm32f2xx_hal_pwr.c stm32f2xx_hal_flash.c stm32f2xx_hal_uart.c stm32f2xx_hal_dma.c stm32f2xx_hal_pcd_ex.c stm32f2xx_hal_sram.c stm32f2xx_hal_cortex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal.c stm32f2xx_hal_adc.c
  group Drivers/BSP/STM32F2xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
software components: CMSIS:CORE 4.1.0
