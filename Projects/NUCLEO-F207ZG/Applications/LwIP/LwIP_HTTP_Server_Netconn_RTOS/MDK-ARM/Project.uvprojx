# Keil uVision project Project.uvprojx, settings and files
target STM32F207ZG_NUCLEO_144 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207ZG_NUCLEO_144
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,USE_STM32F2XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Utilities;../../../../../../Utilities/Log
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_dma.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_cortex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_eth.c stm32f2xx_hal_adc.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_flash.c stm32f2xx_hal_rcc.c stm32f2xx_hal_uart.c stm32f2xx_hal_tim.c stm32f2xx_hal_spi.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal.c stm32f2xx_hal_rcc_ex.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: raw.c udp.c sys.c pbuf.c tcp_in.c dns.c mem.c netif.c init.c memp.c inet_chksum.c tcp_out.c timeouts.c tcp.c stats.c def.c ip.c
  group Drivers/BSP/STM32F2xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c queue.c croutine.c list.c
  group Application/User
    ../Src/: app_ethernet.c stm32f2xx_hal_timebase_tim.c main.c ethernetif.c httpserver-netconn.c stm32f2xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Doc
    ../: readme.txt
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4.c ip4_addr.c autoip.c ip4_frag.c etharp.c igmp.c icmp.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c api_lib.c netdb.c netifapi.c err.c netbuf.c api_msg.c sockets.c
  group Middlewares/LwIP/apps/httpd
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
software components: CMSIS:CORE 4.1.0
