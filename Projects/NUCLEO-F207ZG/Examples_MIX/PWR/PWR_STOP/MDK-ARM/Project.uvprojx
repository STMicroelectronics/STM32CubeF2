# Keil uVision project Project.uvprojx, settings and files
target STM32F207ZG-Nucleo (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207ZG-Nucleo
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F207xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,USE_STM32F2XX_NUCLEO_144
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144
  library: MicroLIB
  group Drivers/BSP/STM32F2xx_Nucleo_144
    ../../../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
  group Example/User
    ../Src/: stm32f2xx_hal_msp.c main.c stm32f2xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32f207xx.s
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_rcc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal.c
software components: CMSIS:CORE 4.3.0
