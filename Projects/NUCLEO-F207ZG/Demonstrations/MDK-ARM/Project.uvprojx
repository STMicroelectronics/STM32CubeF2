# Keil uVision project Project.uvprojx, settings and files
target STM32F207ZG_NUCLEO_144 (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207ZG_NUCLEO_144
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F207xx,USE_HAL_DRIVER,USE_STM32F2XX_NUCLEO_144,ADAFRUIT_TFT_JOY_SD_ID802
  c misc: --C99
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F2xx/Include;../../../../Drivers/STM32F2xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F2xx_Nucleo_144;../../../../Drivers/BSP/Adafruit_Shield;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../Drivers/BSP/Components/Common
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F2xx_HAL_Driver
    ../../../../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_flash.c stm32f2xx_hal_dma.c stm32f2xx_hal_spi.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_adc.c stm32f2xx_hal.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_rcc.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c
  group Drivers/CMSIS
    ../Src/: system_stm32f2xx.c
  group Application/User
    ../Src/: main.c fatfs_storage.c stm32f2xx_it.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: stm32_adafruit_lcd.c stm32_adafruit_sd.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F2xx-Nucleo
    ../../../../Drivers/BSP/STM32F2xx_Nucleo_144/: stm32f2xx_nucleo_144.c
  group Middlewares/FatFs/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../../../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
software components: CMSIS:CORE 4.1.0
